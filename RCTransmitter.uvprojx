# Keil uVision project RCTransmitter.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F130C6 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.0
  cpu: IRAM(0x20000000,0x01000) IROM(0x08000000,0x08000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RCTransmitter
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HXTAL_VALUE = 16000000
  c include: .\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Doc
    ./: readme.txt
  group User
    ./User/: main.c delay.c print.c bk2425.c key.c led.c beep.c
software components: CMSIS:CORE 5.4.0, Device:GD32F1x0_StdPeripherals:ADC 3.2.0, Device:GD32F1x0_StdPeripherals:DMA 3.2.0, Device:GD32F1x0_StdPeripherals:EXTI 3.2.0, Device:GD32F1x0_StdPeripherals:GPIO 3.2.0, Device:GD32F1x0_StdPeripherals:MISC 3.2.0, Device:GD32F1x0_StdPeripherals:RCU 3.2.0, Device:GD32F1x0_StdPeripherals:SYSCFG 3.2.0, Device:GD32F1x0_StdPeripherals:TIMER 3.2.0, Device:GD32F1x0_StdPeripherals:USART 3.2.0, Device:GD32F1x0_libopt 3.2.0, Device:Startup 3.2.0
